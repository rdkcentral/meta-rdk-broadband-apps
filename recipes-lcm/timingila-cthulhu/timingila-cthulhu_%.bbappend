FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-timingila-cthulhu-Add-missing-ExecutionUnitList-info.patch"

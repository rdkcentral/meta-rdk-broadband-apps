FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://containers.cfg"
SRC_URI += "file://loop_dev.cfg"


CMDLINE_append = " cgroup_enable=memory cgroup_memory=1 "
